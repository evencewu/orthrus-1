# Keil uVision project STM32L151.uvprojx, settings and files
target STM32L151 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32L151 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L151xB
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;..\wit_c_sdk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32l151xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
    ../wit_c_sdk/: wit_c_sdk.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
