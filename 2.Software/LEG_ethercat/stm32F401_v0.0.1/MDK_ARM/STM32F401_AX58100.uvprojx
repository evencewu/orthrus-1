# Keil uVision project STM32F401_AX58100.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401CBUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401_AX58100 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\CMSIS\include;..\Lib\inc;..\Ethercat\Inc;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group LIB
    ../Lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ECAT_STACK
    ../Ethercat/src/: bootmode.c diag.c ecataoe.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c emcy.c fc1100hw.c mailbox.c objdef.c sdoserv.c eoeappl.c
  group ECAT_SRC
    ../Ethercat/src/: coeappl.c ecatappl.c el9800appl.c foeappl.c aoeappl.c
  group HARDWARE
    ../Hardware/: ADC1.c EXIT.c SPI1.c sys.c Timer.c
    ../Ethercat/port/: el9800hw.c
